## hw/mcdma/Kconfig
```kconfig
config MCDMA
    bool
    default y
    depends on PCI

config MCDMA_CRYPTO
    bool
    default y
    depends on PCI
```
